# Keil uVision project stm32f072rb_lora.uvprojx, settings and files
target stm32f072rb (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f072rb_lora
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  asm include: ..\M0_BLE_LoRa
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ./: sdk_config.h main_init.c main.c
  group BLE
    ./: bluetooth.c
  group LoRa
    ./: lora.c
  group USART
    ./: usart_user.c
software components: CMSIS:CORE 5.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 2.2.3
